/* The host-only oracle of Curry Clock's procedural steam (rd wave 2 Task 12, ruling R165/I5): puffs_of() and
 * steam_draw() copied verbatim from firmware/apps/rd/components/rd_core/curry.c at commit 0d2ba75 (rd-wave2's base,
 * wave 1 Task 15's 448aa84 with the 12a46a8 fix round), with the few names they read (the helpers ifl, icl, cut and
 * px_at, the puff type and the two context fields) copied beside them. It is a test oracle (acceptable test
 * duplication): test_rd_faces renders its reference frames from it, and the face never links it. Never a second
 * production path; never edited to follow the face.
 *
 * Wave 2 replaced the face's steam with a pre-rendered per-wisp loop (rd/faces.h's RD_CU_WISP_*); the look and cost
 * tests (test_rd_cu_loop_look, test_rd_cu_loop_cost) hold that loop to this drawing. */
#include <stdbool.h>
#include <stddef.h>
#include <stdint.h>
#include <string.h>
#include "rd/faces.h"
#include "fk/compose.h"
#include "fk/shapes.h"
#include "omni/blend565.h"
#include "rd_cu_steam_oracle.h"

#define C 233
#define PI 3.14159265359f
#define STEAM_N 120
#define BLOB 32
#define STEAM_X0 128
#define STEAM_X1 349

/* ---- copied from curry.c at 0d2ba75 (the helpers and the types steam_draw reads) */
static int ifl(float v)
{
    const int i = (int)v;
    return (float)i > v ? i - 1 : i;
}
static int icl(float v)
{
    const int i = (int)v;
    return (float)i < v ? i + 1 : i;
}
static omni_rect_t cut(omni_rect_t a, omni_rect_t b)
{
    omni_rect_t r = a;
    if (r.x0 < b.x0) r.x0 = b.x0;
    if (r.y0 < b.y0) r.y0 = b.y0;
    if (r.x1 > b.x1) r.x1 = b.x1;
    if (r.y1 > b.y1) r.y1 = b.y1;
    return r;
}
static uint16_t *px_at(uint16_t *fb, int stride, omni_rect_t clip, int x, int y)
{
    return fb + (ptrdiff_t)(y - clip.y0) * stride + (x - clip.x0);
}

/* a puff: its square's top-left, the blob's texels per pixel, its alpha (Q12) and its rows [iy0, iy1) */
typedef struct { float x0, y0, inv; uint16_t aq; int16_t iy0, iy1; } puff_t;

/* the two fields of curry.c's cu_t and three of its cu_state_t that the copy reads */
typedef struct {
    fk_img_t blob;
    puff_t puff[STEAM_N];
    uint16_t acc[3][STEAM_X1 - STEAM_X0];
} cu_t;
typedef struct {
    uint32_t T;   /* its clock, ms */
    float amt;    /* its strength */
    bool red;
} cu_state_t;

/* ---- puffs_of() and steam_draw(), verbatim (curry.c:731-819 at 0d2ba75) */
static unsigned puffs_of(const cu_state_t *s, puff_t *P)
{
    static const float OX[4] = {-50.f, -12.f, 24.f, 60.f};
    unsigned n = 0;
    const float wob = (float)(s->T % 50265u) / 800.f;   /* t / 800, its period 2 pi x 8 000 ms near enough */
    for (int w = 0; w < 4; w++) {
        const float base = (float)(((s->T % 60000u) * (uint32_t)(28 + 4 * w)) % 60000u) / 60000.f;
        for (int k = 0; k < 30; k++) {
            float life = base + (float)k / 30.f + 0.23f * (float)w;
            life -= (float)ifl(life);
            float sn, cs, sp, cp;
            fk_sincos(life * PI, &sp, &cp);
            const float a = s->amt * 0.085f * sp;
            if (!(a > 0)) continue;
            fk_sincos(life * 7.f + wob + 1.7f * (float)w, &sn, &cs);
            const float y = (float)C + 30.f - life * 220.f, x = (float)C + OX[w] + sn * (6.f + life * 22.f);
            const float h = 7.f + life * 20.f;
            puff_t *p = &P[n];
            p->x0 = x - h, p->y0 = y - h, p->inv = (float)BLOB / (2.f * h);
            p->aq = (uint16_t)(a * 4096.f + 0.5f);
            p->iy0 = (int16_t)ifl(y - h), p->iy1 = (int16_t)icl(y + h);
            if (p->aq) n++;
        }
    }
    return n;
}

static void steam_draw(const cu_t *k, const cu_state_t *s, uint16_t *fb, int stride, omni_rect_t clip)
{
    const omni_rect_t r = cut(clip, RD_CU_STEAM);
    if (r.x0 >= r.x1 || r.y0 >= r.y1) return;
    cu_t *m = (cu_t *)(uintptr_t)k;   /* the scratch: draw()'s one write outside its frame (see the header) */
    puff_t *P = m->puff;
    uint16_t(*acc)[STEAM_X1 - STEAM_X0] = m->acc;
    const unsigned np = puffs_of(s, P);
    const uint32_t cr = 255, cg = s->red ? 150 : 248, cb = s->red ? 120 : 236;
    const int w = r.x1 - r.x0;
    const uint8_t *blob = k->blob.a;
    for (int y = r.y0; y < r.y1; y++) {
        memset(m->acc, 0, sizeof m->acc);
        bool any = false;
        for (unsigned i = 0; i < np; i++) {
            const puff_t *p = &P[i];
            if (y < p->iy0 || y >= p->iy1) continue;
            /* drawImage(blob, x - s, y - s, 2 s, 2 s): the source point of each pixel centre, bilinear, edge-clamped */
            const float vy = ((float)y + 0.5f - p->y0) * p->inv - 0.5f;
            if (!(vy > -1.f && vy < (float)BLOB)) continue;
            const int vq = (int)((vy + 1.f) * 256.f) - 256;
            int j0 = vq >> 8;
            const uint32_t fy = (uint32_t)(vq & 255);
            int j1 = j0 + 1;
            j0 = j0 < 0 ? 0 : j0 > BLOB - 1 ? BLOB - 1 : j0;
            j1 = j1 < 0 ? 0 : j1 > BLOB - 1 ? BLOB - 1 : j1;
            const int ix0 = ifl(p->x0), ix1 = icl(p->x0 + (float)BLOB / p->inv);
            const int xa = ix0 > r.x0 ? ix0 : r.x0, xb = ix1 < r.x1 ? ix1 : r.x1;
            for (int x = xa; x < xb; x++) {
                const float ux = ((float)x + 0.5f - p->x0) * p->inv - 0.5f;
                if (!(ux > -1.f && ux < (float)BLOB)) continue;
                const int uq = (int)((ux + 1.f) * 256.f) - 256;
                int i0 = uq >> 8;
                const uint32_t fx = (uint32_t)(uq & 255);
                int i1 = i0 + 1;
                i0 = i0 < 0 ? 0 : i0 > BLOB - 1 ? BLOB - 1 : i0;
                i1 = i1 < 0 ? 0 : i1 > BLOB - 1 ? BLOB - 1 : i1;
                const uint32_t top = blob[j0 * BLOB + i0] * (256u - fx) + blob[j0 * BLOB + i1] * fx;
                const uint32_t bot = blob[j1 * BLOB + i0] * (256u - fx) + blob[j1 * BLOB + i1] * fx;
                const uint32_t bv = (top * (256u - fy) + bot * fy) >> 16;   /* 0..255 */
                if (!bv) continue;
                const uint32_t wq = bv * (uint32_t)p->aq;                     /* x 2^12 */
                const int o = x - r.x0;
                const uint32_t ar = acc[0][o] + ((cr * wq) >> 16), ag = acc[1][o] + ((cg * wq) >> 16),
                               ab = acc[2][o] + ((cb * wq) >> 16);
                acc[0][o] = (uint16_t)(ar > 0xFFFFu ? 0xFFFFu : ar);
                acc[1][o] = (uint16_t)(ag > 0xFFFFu ? 0xFFFFu : ag);
                acc[2][o] = (uint16_t)(ab > 0xFFFFu ? 0xFFFFu : ab);
                any = true;
            }
        }
        if (!any) continue;
        uint16_t *d = px_at(fb, stride, clip, r.x0, y);
        for (int x = 0; x < w; x++) {
            const uint32_t ar = (acc[0][x] + 8u) >> 4, ag = (acc[1][x] + 8u) >> 4, ab = (acc[2][x] + 8u) >> 4;
            if (!(ar | ag | ab)) continue;
            const uint32_t R = (uint32_t)omni_ex_r(d[x]) + ar, G = (uint32_t)omni_ex_g(d[x]) + ag,
                           B = (uint32_t)omni_ex_b(d[x]) + ab;
            d[x] = omni_pack565((int)(R > 255 ? 255 : R), (int)(G > 255 ? 255 : G), (int)(B > 255 ? 255 : B));
        }
    }
}

/* the 32 x 32 A8 glow plane the copy samples: the bytes of the former asset rd_cu_steam.bin (its 12-byte header
 * dropped), kept here now that the face's loop (rd_cu_wisp) replaced the asset on the device */
static const uint8_t STEAM_BLOB[BLOB * BLOB] = {
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x03,0x04,0x05,0x05,0x04,0x03,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x05,0x08,0x0b,0x0d,0x0e,0x0f,0x0f,0x0e,0x0d,0x0b,0x08,0x05,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x05,0x0a,0x0e,0x11,0x14,0x16,0x18,0x18,0x18,0x18,0x16,0x14,0x11,0x0e,0x0a,0x05,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x09,0x0e,0x13,0x17,0x1b,0x1e,0x20,0x21,0x22,0x22,0x21,0x20,0x1e,0x1b,0x17,0x13,0x0e,0x09,0x03,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x04,0x0b,0x11,0x16,0x1b,0x20,0x24,0x27,0x2a,0x2b,0x2c,0x2c,0x2b,0x2a,0x27,0x24,0x20,0x1b,0x16,0x11,0x0b,0x04,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x04,0x0b,0x12,0x18,0x1e,0x24,0x29,0x2d,0x30,0x33,0x35,0x36,0x36,0x35,0x33,0x30,0x2d,0x29,0x24,0x1e,0x18,0x12,0x0b,0x04,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x03,0x0b,0x12,0x19,0x20,0x26,0x2c,0x31,0x36,0x3a,0x3d,0x3f,0x40,0x40,0x3f,0x3d,0x3a,0x36,0x31,0x2c,0x26,0x20,0x19,0x12,0x0b,0x03,0x00,0x00,0x00,
    0x00,0x00,0x00,0x09,0x11,0x18,0x20,0x27,0x2e,0x34,0x3a,0x3f,0x43,0x46,0x48,0x49,0x49,0x48,0x46,0x43,0x3f,0x3a,0x34,0x2e,0x27,0x20,0x18,0x11,0x09,0x00,0x00,0x00,
    0x00,0x00,0x05,0x0e,0x16,0x1e,0x26,0x2e,0x35,0x3c,0x42,0x47,0x4c,0x4f,0x52,0x53,0x53,0x52,0x4f,0x4c,0x47,0x42,0x3c,0x35,0x2e,0x26,0x1e,0x16,0x0e,0x05,0x00,0x00,
    0x00,0x01,0x0a,0x13,0x1b,0x24,0x2c,0x34,0x3c,0x43,0x49,0x4f,0x55,0x59,0x5b,0x5d,0x5d,0x5b,0x59,0x55,0x4f,0x49,0x43,0x3c,0x34,0x2c,0x24,0x1b,0x13,0x0a,0x01,0x00,
    0x00,0x05,0x0e,0x17,0x20,0x29,0x31,0x3a,0x42,0x49,0x51,0x57,0x5d,0x62,0x65,0x68,0x68,0x65,0x62,0x5d,0x57,0x51,0x49,0x42,0x3a,0x31,0x29,0x20,0x17,0x0e,0x05,0x00,
    0x00,0x08,0x11,0x1b,0x24,0x2d,0x36,0x3f,0x47,0x4f,0x57,0x5f,0x65,0x72,0x7d,0x83,0x83,0x7d,0x72,0x65,0x5f,0x57,0x4f,0x47,0x3f,0x36,0x2d,0x24,0x1b,0x11,0x08,0x00,
    0x01,0x0b,0x14,0x1e,0x27,0x30,0x3a,0x43,0x4c,0x55,0x5d,0x65,0x78,0x89,0x97,0x9e,0x9e,0x97,0x89,0x78,0x65,0x5d,0x55,0x4c,0x43,0x3a,0x30,0x27,0x1e,0x14,0x0b,0x01,
    0x03,0x0d,0x16,0x20,0x2a,0x33,0x3d,0x46,0x4f,0x59,0x62,0x72,0x89,0x9e,0xaf,0xb9,0xb9,0xaf,0x9e,0x89,0x72,0x62,0x59,0x4f,0x46,0x3d,0x33,0x2a,0x20,0x16,0x0d,0x03,
    0x04,0x0e,0x18,0x21,0x2b,0x35,0x3f,0x48,0x52,0x5b,0x65,0x7d,0x97,0xaf,0xc5,0xd4,0xd4,0xc5,0xaf,0x97,0x7d,0x65,0x5b,0x52,0x48,0x3f,0x35,0x2b,0x21,0x18,0x0e,0x04,
    0x05,0x0f,0x18,0x22,0x2c,0x36,0x40,0x49,0x53,0x5d,0x68,0x83,0x9e,0xb9,0xd4,0xec,0xec,0xd4,0xb9,0x9e,0x83,0x68,0x5d,0x53,0x49,0x40,0x36,0x2c,0x22,0x18,0x0f,0x05,
    0x05,0x0f,0x18,0x22,0x2c,0x36,0x40,0x49,0x53,0x5d,0x68,0x83,0x9e,0xb9,0xd4,0xec,0xec,0xd4,0xb9,0x9e,0x83,0x68,0x5d,0x53,0x49,0x40,0x36,0x2c,0x22,0x18,0x0f,0x05,
    0x04,0x0e,0x18,0x21,0x2b,0x35,0x3f,0x48,0x52,0x5b,0x65,0x7d,0x97,0xaf,0xc5,0xd4,0xd4,0xc5,0xaf,0x97,0x7d,0x65,0x5b,0x52,0x48,0x3f,0x35,0x2b,0x21,0x18,0x0e,0x04,
    0x03,0x0d,0x16,0x20,0x2a,0x33,0x3d,0x46,0x4f,0x59,0x62,0x72,0x89,0x9e,0xaf,0xb9,0xb9,0xaf,0x9e,0x89,0x72,0x62,0x59,0x4f,0x46,0x3d,0x33,0x2a,0x20,0x16,0x0d,0x03,
    0x01,0x0b,0x14,0x1e,0x27,0x30,0x3a,0x43,0x4c,0x55,0x5d,0x65,0x78,0x89,0x97,0x9e,0x9e,0x97,0x89,0x78,0x65,0x5d,0x55,0x4c,0x43,0x3a,0x30,0x27,0x1e,0x14,0x0b,0x01,
    0x00,0x08,0x11,0x1b,0x24,0x2d,0x36,0x3f,0x47,0x4f,0x57,0x5f,0x65,0x72,0x7d,0x83,0x83,0x7d,0x72,0x65,0x5f,0x57,0x4f,0x47,0x3f,0x36,0x2d,0x24,0x1b,0x11,0x08,0x00,
    0x00,0x05,0x0e,0x17,0x20,0x29,0x31,0x3a,0x42,0x49,0x51,0x57,0x5d,0x62,0x65,0x68,0x68,0x65,0x62,0x5d,0x57,0x51,0x49,0x42,0x3a,0x31,0x29,0x20,0x17,0x0e,0x05,0x00,
    0x00,0x01,0x0a,0x13,0x1b,0x24,0x2c,0x34,0x3c,0x43,0x49,0x4f,0x55,0x59,0x5b,0x5d,0x5d,0x5b,0x59,0x55,0x4f,0x49,0x43,0x3c,0x34,0x2c,0x24,0x1b,0x13,0x0a,0x01,0x00,
    0x00,0x00,0x05,0x0e,0x16,0x1e,0x26,0x2e,0x35,0x3c,0x42,0x47,0x4c,0x4f,0x52,0x53,0x53,0x52,0x4f,0x4c,0x47,0x42,0x3c,0x35,0x2e,0x26,0x1e,0x16,0x0e,0x05,0x00,0x00,
    0x00,0x00,0x00,0x09,0x11,0x18,0x20,0x27,0x2e,0x34,0x3a,0x3f,0x43,0x46,0x48,0x49,0x49,0x48,0x46,0x43,0x3f,0x3a,0x34,0x2e,0x27,0x20,0x18,0x11,0x09,0x00,0x00,0x00,
    0x00,0x00,0x00,0x03,0x0b,0x12,0x19,0x20,0x26,0x2c,0x31,0x36,0x3a,0x3d,0x3f,0x40,0x40,0x3f,0x3d,0x3a,0x36,0x31,0x2c,0x26,0x20,0x19,0x12,0x0b,0x03,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x04,0x0b,0x12,0x18,0x1e,0x24,0x29,0x2d,0x30,0x33,0x35,0x36,0x36,0x35,0x33,0x30,0x2d,0x29,0x24,0x1e,0x18,0x12,0x0b,0x04,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x04,0x0b,0x11,0x16,0x1b,0x20,0x24,0x27,0x2a,0x2b,0x2c,0x2c,0x2b,0x2a,0x27,0x24,0x20,0x1b,0x16,0x11,0x0b,0x04,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x09,0x0e,0x13,0x17,0x1b,0x1e,0x20,0x21,0x22,0x22,0x21,0x20,0x1e,0x1b,0x17,0x13,0x0e,0x09,0x03,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x05,0x0a,0x0e,0x11,0x14,0x16,0x18,0x18,0x18,0x18,0x16,0x14,0x11,0x0e,0x0a,0x05,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x05,0x08,0x0b,0x0d,0x0e,0x0f,0x0f,0x0e,0x0d,0x0b,0x08,0x05,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x03,0x04,0x05,0x05,0x04,0x03,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00
};

/* ---- the oracle's entry points (not of the copy) */
static cu_t oracle_ctx;   /* host only: the tests run on one thread */

void rd_cu_steam_oracle(uint32_t T, float amt, bool red, uint16_t *fb, int stride, omni_rect_t clip)
{
    const cu_state_t s = {T, amt, red};
    oracle_ctx.blob.a = STEAM_BLOB;
    oracle_ctx.blob.w = oracle_ctx.blob.h = BLOB;
    steam_draw(&oracle_ctx, &s, fb, stride, clip);
}

/* the copy's inner-loop count over the whole of RD_CU_STEAM: every (puff, pixel) whose bilinear sample it works out
 * (the loop bounds and the two range tests of steam_draw, nothing drawn) */
unsigned long rd_cu_steam_oracle_samples(uint32_t T, float amt)
{
    const cu_state_t s = {T, amt, false};
    const omni_rect_t r = RD_CU_STEAM;
    const unsigned np = puffs_of(&s, oracle_ctx.puff);
    unsigned long n = 0;
    for (int y = r.y0; y < r.y1; y++)
        for (unsigned i = 0; i < np; i++) {
            const puff_t *p = &oracle_ctx.puff[i];
            if (y < p->iy0 || y >= p->iy1) continue;
            const float vy = ((float)y + 0.5f - p->y0) * p->inv - 0.5f;
            if (!(vy > -1.f && vy < (float)BLOB)) continue;
            const int ix0 = ifl(p->x0), ix1 = icl(p->x0 + (float)BLOB / p->inv);
            const int xa = ix0 > r.x0 ? ix0 : r.x0, xb = ix1 < r.x1 ? ix1 : r.x1;
            for (int x = xa; x < xb; x++) {
                const float ux = ((float)x + 0.5f - p->x0) * p->inv - 0.5f;
                n += ux > -1.f && ux < (float)BLOB;
            }
        }
    return n;
}
